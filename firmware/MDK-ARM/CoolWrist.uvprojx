# Keil uVision project CoolWrist.uvprojx, settings and files
target CoolWrist (6240000::V6.24::ARMCLANG)
  device: STM32U5A5ZJTx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000-0x2026FFFF) IROM(0x08000000-0x83FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: CoolWrist +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_NUCLEO_64,USE_HAL_DRIVER,STM32U5A5xx
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/BSP/STM32U5xx_Nucleo;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x270000
  group Application/MDK-ARM
    ./: startup_stm32u5a5xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c gpdma.c i2c.c icache.c spi.c tim.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Drivers/BSP/STM32U5xx_Nucleo
    ../Drivers/BSP/STM32U5xx_Nucleo/: stm32u5xx_nucleo.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_usart.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
software components: CMSIS:CORE 5.6.0
